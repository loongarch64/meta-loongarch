SRCREV_edk2           ?= "69e59545b14739e004d3f0452411e195d2a3c197"
SRCREV_edk2-platforms ?= "4811c37ae347c68d36054d8176f2f5b9e9090298"

require edk2-firmware.inc
