VALGRIND:loongarch32 = ""
VALGRIND:loongarch64 = ""

SYSTEMTAP:loongarch32 = ""
SYSTEMTAP:loongarch64 = ""

LTTNGTOOLS:loongarch32 = ""
LTTNGTOOLS:loongarch64 = ""
