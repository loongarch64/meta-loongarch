EXTRA_OECONF:remove:loongarch64 = "--enable-gold"