CFLAGS:append:loongarch64 = " ${LCL_STOP_SERVICES}"
