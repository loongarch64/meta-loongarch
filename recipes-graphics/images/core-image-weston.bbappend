QB_MEM:qemuloongarch64 = "-m 2048"