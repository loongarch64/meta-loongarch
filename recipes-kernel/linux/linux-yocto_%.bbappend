KCONFIG_MODE="--alldefconfig"

KBUILD_DEFCONFIG:loongarch64 ?="loongson3_defconfig"

KERNEL_DANGLING_FEATURES_WARN_ONLY="1"
