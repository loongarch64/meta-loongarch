PACKAGECONFIG:remove:loongarch32 = "libunwind"
PACKAGECONFIG:remove:loongarch64 = "libunwind"

PERF_SRC += " arch/loongarch "
